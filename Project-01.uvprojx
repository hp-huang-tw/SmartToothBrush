# Keil uVision project Project-01.uvprojx, settings and files
target F429 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32F4XX,USE_STDPERIPH_DRIVER
  c include: .\lib\mylib;.\lib\CMSIS\Include;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\sys;.\lib\CMSIS\Device\ST\STM32F4xx\Include;.\TM;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f429_439xx.s
  group lib
    ./lib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_spi.c stm32f4xx_flash.c
  group user
    ./user/: init_interface.c smartsensor.c hw_config.c defines.h main.c
  group sys
    ./sys/: stm32f4xx_it.c system_stm32f4xx.c
  group TM
    ./TM/: tm_stm32f4_disco.c tm_stm32f4_fonts.c tm_stm32f4_i2c.c tm_stm32f4_ili9341.c tm_stm32f4_spi.c
software components: Device:StdPeriph Drivers:I2C 1.3.0
